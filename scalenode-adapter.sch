File: scalenode-adapter.sch (KiCad schematic (older format))
At the start: 0 parts

Commit message: Update naming convention
